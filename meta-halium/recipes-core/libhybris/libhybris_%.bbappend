CFLAGS:append:halium9-gsi = " -DQTI_BSP -DQCOM_HARDWARE"
CXXFLAGS:append:halium9-gsi = " -DQTI_BSP -DQCOM_HARDWARE"
