FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_onyx = "onyx"
COMPATIBLE_MACHINE_bacon = "bacon"
COMPATIBLE_MACHINE_dumpling = "dumpling"
