# we have android-headers-onyx / android-headers-bacon / android-headers-dumpling
COMPATIBLE_MACHINE_onyx = "(^onyx$)"
COMPATIBLE_MACHINE_bacon = "(^bacon$)"
COMPATIBLE_MACHINE_dumpling = "(^dumpling$)"
